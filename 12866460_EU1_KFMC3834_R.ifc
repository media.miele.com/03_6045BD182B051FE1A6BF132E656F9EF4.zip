Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: ab62cd6e-3307-4d14-9c8c-a073d586e8cf, NumberOfSaves: 1]
File name: 0001
Time: 2026-08-15T00:08:27+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12866460_EU1_KFMC3834_R:38383400_EU1_12866460_KFMC3834_R, (2)
In: Default
Type - Material: <Unnamed>, z_Miele_Design_OBSW, z_Miele_Connection_Connection_Modul, z_Miele_Connection_Connection_Water_IN
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 756 mm; Height: 2123 mm; Depth: 608 mm
Pset_BuildingElementProxyCommon - Reference: 38383400_EU1_12866460_KFMC3834_R; sets with these values: 2
